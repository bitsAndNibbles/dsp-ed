options:
  parameters:
    author: Jonathan
    generate_options: qt_gui
    id: usrp_rx_to_zmq
    output_language: python
    title: usrp_rx_to_zmq
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Receive Freq
    type: real
    value: 144.92e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Receive Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '76'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, 180000)
    clock_rate: 30.72e6
    dev_args: '"recv_buff_size=12288,recv_frame_size=1544"'
    gain0: gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
