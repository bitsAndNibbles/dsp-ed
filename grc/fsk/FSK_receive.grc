options:
  parameters:
    author: sneak
    generate_options: qt_gui
    id: FSK_Receive
    output_language: python
    title: FSK Receive
  states: {}

blocks:
- name: demod_symbol_repeat
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tab@1: 0, 1, 1, 1'
    label: demod_symbol_repeat
    type: int
    value: '100'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '98'
    value: '50'
  states: {}
- name: max_messages
  id: variable
  parameters:
    value: '200'
  states: {}
- name: num_src_bits
  id: variable
  parameters:
    comment: 8675309 as nibbles
    value: '24'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 903.1e6+15e3
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: samp_rate*1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '48'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/jonathan/dsp-ed/data/demod-bits.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jonathan/Desktop/fsk_shifted10k.512000.cplx
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_src_bits*max_messages
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: demod_symbol_repeat
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(demod_symbol_repeat/2)
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: rx_samp_rate
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 7e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 'tab@1: 1, 0, 1, 2'
    name: Filtered
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: RF
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'tab@1: 4, 0, 1, 2'
    name: Symbols (Raster)
    ncols: num_src_bits*demod_symbol_repeat
    nrows: '256'
    samp_rate: samp_rate
    type: byte
    x_end_value: num_src_bits
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: num_src_bits*demod_symbol_repeat*3
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'tab@1: 3, 0, 1, 2'
    name: Symbols (Streaming)
    size: num_src_bits*demod_symbol_repeat*3
    srate: samp_rate
    tr_delay: '100e-6'
    type: float
    ymin: '-0.1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rx_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rx_samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: fsk_mod_source
    label1: A/D
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: rx_freq
    dev_addr: '"serial=31993BB"'
    gain0: gain
    samp_rate: rx_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: raw_iq_src
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: demod_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: raw_iq_src
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: demod_bits
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4938
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:4938
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_file_source_0, '0', blocks_skiphead_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_head_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_keep_one_in_n_0, '0', zeromq_pub_sink_0, '0']
- [blocks_skiphead_0, '0', virtual_sink_1, '0']
- [digital_binary_slicer_fb_0_0, '0', virtual_sink_2, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_1, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_3, '0', blocks_char_to_float_0, '0']
- [virtual_source_3, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_3, '0', qtgui_time_raster_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
